require rbz-image-full.bb

SUMMARY = "RBZ machine learning image (CPU, GPU and NPU)"

IMAGE_INSTALL += "packagegroup-rbz-ml"
